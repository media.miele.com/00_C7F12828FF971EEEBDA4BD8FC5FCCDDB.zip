Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2024-04-02T15:52:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Apr 02 15:52:50 2024 * Host: DEGTL11901 * Database: C:\Users\deschvi\AppData\Local\Temp\68fd66f4-041b-4e9d-bf4a-109374d260d1\ce8f38de-a03f-48e0-80a7-28de465e5d6d\ifc * Database version: 5507 * Database creation date: Tue Apr 02 15:52:49 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Apr 02 15:52:49 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Apr 02 15:52:49 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12579060_CDN_CVA7875_OBSWMATT:29787521_CDN_12579060_CVA7875_OBSWMATT, (2)
In: Default
Type - Material: z_Miele_Design_Glass, z_Miele_Design_CLST, z_Miele_Design_OBSW, z_Miele_Design_Zinc_Steel, z_Miele_Connection_Water_IN, z_Miele_Connection_Electric, z_Miele_Design_Steel_Chrom, z_Miele_Design_Glass Black
Type - Pset_BuildingElementProxyCommon - Reference: 29787521_CDN_12579060_CVA7875_OBSWMATT
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 29787521_CDN_12579060_CVA7875_OBSWMATT
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 595 mm; Height: 455 mm; Depth: 475 mm

# IfcDistributionPort, Port_353128
Description: Flow; FlowDirection: SOURCEANDSINK
